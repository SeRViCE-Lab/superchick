Commit message: minor fizes in mjcf code

File: superchick/models/superchick.urdf (robot description, URDF)
Before this commit: robot superchick, 12 links, 12 joints
Joints:
- removed joint leftleg_to_tabletop
